# Autodesk Inventor part: 슬라이드
## iProperties
Created: 2014-04
Part Number: 슬라이드
Document SubType Name: Modeling
Designer: SeoGD™ [esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [esajin.kr]
