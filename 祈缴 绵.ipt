# Autodesk Inventor part: 편심 축
## iProperties
Created: 2013-05
Part Number: 편심 축
Document SubType Name: Modeling
Designer: SeoGD™
Density: 1 g/cm^3
Author: SeoGD™
