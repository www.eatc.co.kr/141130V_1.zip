# Autodesk Inventor part: 로드
## iProperties
Created: 2013-05
Part Number: 로드
Document SubType Name: Modeling
Designer: SeoGD™
Density: 1 g/cm^3
Author: SeoGD™
