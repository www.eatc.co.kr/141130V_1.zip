# Autodesk Inventor part: 본체
## iProperties
Created: 2013-05
Part Number: 본체
Document SubType Name: Modeling
Designer: SeoGD™
Density: 1 g/cm^3
Author: SeoGD™
