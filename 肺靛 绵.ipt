# Autodesk Inventor part: 로드 축
## iProperties
Created: 2013-05
Part Number: 로드 축
Document SubType Name: Modeling
Designer: SeoGD™
Density: 1 g/cm^3
Author: SeoGD™
